FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://core-network.cfg"
