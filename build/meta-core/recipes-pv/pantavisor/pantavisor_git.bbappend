FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://0004-prefer-curl-for-pvcontrol.patch"
